# Keil uVision project Transition.uvprojx, settings and files
target Transition (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: Transition +hex
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\FWLIB\inc;..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\HARDWARE;..\HARDWARE\CAN;..\HARDWARE\LED;..\HARDWARE\MALLOC;..\APPLICATION\CAN_APP;..\APPLICATION\LED_APP;..\HARDWARE\STEPMOTOR;..\HARDWARE\WQ25XX;..\HARDWARE\BEEP;..\HARDWARE\TRACKMISSION;..\HARDWARE\UART;..\APPLICATION\UART_APP;..\APPLICATION\MODBUS_APP;..\HARDWARE\TIMER;..\HARDWARE\CRC;..\HARDWARE\Modbus;..\DATA
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group DATA
    ../DATA/: GlobalData.c GlobalData.h Macro.h Structure.h
  group USER
    ./: Application.c myconfig.c stm32f4xx_it.c system_stm32f4xx.c TransitionFunction.c
  group APPLICATION
    ../APPLICATION/CAN_APP/: Can_App.c
    ../APPLICATION/LED_APP/: Led_App.c
    ../APPLICATION/STEPMOTOR_App/: StepMotor_App.c
    ../APPLICATION/TRACKMISSION_APP/: TrackMission_APP.c
    ../APPLICATION/TIMER/: Timer_APP.c
    ../APPLICATION/MODBUS_APP/: ModBus_APP.c
    ../APPLICATION/STATE_APP/: State_APP.c
  group HARDWARE
    ../HARDWARE/TRACKMISSION/: TrackMission_Dri.c
    ../HARDWARE/STEPMOTOR/: StepMotor_Dir.c
    ../HARDWARE/CAN/: Can_Dri.c
    ../HARDWARE/BEEP/: beep_Dri.c
    ../HARDWARE/LED/: Led_Dri.c
    ../HARDWARE/WQ25XX/: W25QXX_Dir.c
    ../HARDWARE/MALLOC/: malloc.c
    ../HARDWARE/UART/: Uart_Drv.c
    ../HARDWARE/TIMER/: Timer_Dri.c
    ../HARDWARE/CRC/: CRC.c
    ../HARDWARE/Modbus/: ModBus.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_spi.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu_c.c os_cpu_a.asm os_cpu.h
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h
  group DAILY RECORD
    ../: daily record.txt 版本改动日志.txt
